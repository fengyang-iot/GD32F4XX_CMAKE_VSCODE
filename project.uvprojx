# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F425RE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, USE_STDPERIPH_DRIVER, GD32F425, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__
  c include: .;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\include;rt-thread\components\libc\posix\io\poll;rt-thread\components\drivers\include;rt-thread\libcpu\arm\cortex-m4;board;rt-thread\components\libc\posix\io\epoll;rt-thread\components\finsh;rt-thread\components\drivers\include;libraries\GD32F4xx_Firmware_Library\CMSIS;libraries\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include;libraries\gd32_drivers;applications;rt-thread\components\drivers\include;libraries\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include;rt-thread\components\libc\compilers\common\include;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\posix\io\eventfd;rt-thread\components\libc\posix\ipc;rt-thread\libcpu\arm\common;rt-thread\components\drivers\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    applications/: main.c io.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    board/: board.c
    libraries/GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f4xx.s
    libraries/gd32_drivers/: drv_gpio.c drv_soft_i2c.c drv_usart.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    libraries/GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_i2c.c gd32f4xx_syscfg.c gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_misc.c gd32f4xx_usart.c
    libraries/GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
software components: CMSIS:CORE 5.5.0
